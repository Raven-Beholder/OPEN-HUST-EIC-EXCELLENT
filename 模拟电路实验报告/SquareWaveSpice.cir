** SquareWave **
*
* NI Multisim to SPICE Netlist Export
* Generated by: ravenchen
* Wed, Dec 30, 2020 12:42:30
*

*## Multisim Component C15 ##*
cC15 29 33 2.2e-005

*## Multisim Component C14 ##*
cC14 30 34 2.2e-005

*## Multisim Component C8 ##*
cC8 13 11 1.2e-009

*## Multisim Instrument XSC2 ##*

*## Multisim Instrument XSC1 ##*

*## Multisim Component R32 ##*
rR32 31 32 1000 vresR32
.model vresR32 r(  )

*## Multisim Component R30 ##*
rR30 31 34 1000 vresR30
.model vresR30 r(  )

*## Multisim Component R31 ##*
rR31 31 33 1000 vresR31
.model vresR31 r(  )

*## Multisim Component R25 ##*
rR25 25 26 25 vresR25
.model vresR25 r(  )

*## Multisim Component U6 ##*
xU6_B 32 31 0 VEE VCC NE5532_2__OPAMP__1

*## Multisim Component R29 ##*
* !!!BEGIN-INTERACT
*  : increment     ++++f4 ;
*  : setresistance ++++f6 ;
*  0.0             constant  mindval
*  100.0           constant  maxdval
*  0.0             VARIABLE  resistance
*  50.0            VARIABLE  setting
*  0.0             VARIABLE  setfactor
*  0.0             VARIABLE  zeroadj
*  0.0             VARIABLE  tresistance
*  0               VARIABLE  num_stored
*  0.0             VARIABLE  setresval
*  0	           VARIABLE  flag
*
*  :MAP_KEYBOARD_INPUT ++++k1 1 ++++K1  -1 ;
*
*  : UPDATE_SETTINGS
*      *flag 0 = if
*      LOAD_FICL_VARIABLES
*      ==>_*num_stored
*      ==>_*num_stored
*      *num_stored 0 > if
*         ==>_*setting
*         ==>_*setresval
*         *setresval tresistance f./ ==>_*setfactor
*         *setresval SET_INSTANCE Resistor ::R R1  resistance
*         tresistance *setresval f.- SET_INSTANCE Resistor ::R R2  resistance
*      endif
*      1 ==>_*flag
*      endif
*      setresistance ==>_*tresistance
*      0.01 *setting f.* ==>_*zeroadj
*      *zeroadj PERCENT SET_ANIMATION_TEXT
*      0.0000001 0.9999999 *zeroadj f.min f.max  ==>_*setfactor
*      *setfactor *tresistance f.* resistance GRADUAL_CHANGE_AT_RUN
*      *setfactor tresistance f.* *setting 2 0
*      STORE_FICL_VARIABLES
*  ;
*
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*    value                       SET_INSTANCE Resistor ::R R1  resistance
*    *tresistance  value f.-       SET_INSTANCE Resistor ::R R2  resistance
*  ;
*
*  :KEYBOARD_INPUT locals| shift_state |
*     shift_state (float) increment f.* *setting  f.+  ==>_*setting
*     mindval maxdval *setting f.min f.max ==>_*setting
*     UPDATE_SETTINGS
*  ;
*
*  :BEGIN_PLOT
*     UPDATE_SETTINGS
*  ;
*
*
*  : INIT_SLIDER
*      maxdval mindval 3 IMOUSE_SET
*  ;
*
*  : ON_IMOUSE_EVENT locals| eType fValue |
*    eType 9 = if
*      -1
*      fValue ==>_*setting
*    else
*      0
*    endif
*    UPDATE_SETTINGS
*  ;
*
*  : GET_INTERACT_VALUE locals| eType |
*      eType 0 = if
*        *setting
*      else eType 1 = if
*        mindval
*      else eType 2 = if
*        maxdval
*      else eType 3 = if
*        increment
*      else
*        0
*      endif endif endif endif
*  ;
*
*  : SET_INTERACT_VALUE locals| eType fValue |
*      eType 0 = if
*        fValue ==>_*setting
*      endif
*      UPDATE_SETTINGS
*  ;
*
*  :ON_USER_UPDATE
*    UPDATE_SETTINGS
*    INIT_SLIDER
*  ;
*
*  :BEGIN_ANALYSIS
*    UPDATE_SETTINGS
*  ;
*
* !!!END-INTERACT
xR29 0 28 R29_OPEN_3  PotentiometerR29
.subckt PotentiometerR29 1 2 3
R1 1 2  1e-3
R2 2 3  1e-3
.ends

*## Multisim Component R28 ##*
rR28 27 29 10000 vresR28
.model vresR28 r(  )

*## Multisim Component R27 ##*
rR27 23 27 10000 vresR27
.model vresR27 r(  )

*## Multisim Component R9 ##*
rR9 3 11 66500 vresR9
.model vresR9 r(  )

*## Multisim Component C13 ##*
cC13 23 28 1e-009

*## Multisim Component C3 ##*
cC3 5 7 1.2e-008

*## Multisim Component VEE ##*
VEEVEE  VEE 0 dc -15

*## Multisim Component VCC ##*
VCCVCC  VCC 0 dc 15

*## Multisim Component U6 ##*
xU6_A 29 27 28 VEE VCC NE5532_2__OPAMP__1

*## Multisim Component R26 ##*
rR26 26 30 800 vresR26
.model vresR26 r(  )

*## Multisim Component R24 ##*
rR24 24 25 400 vresR24
.model vresR24 r(  )

*## Multisim Component R23 ##*
rR23 19 24 100 vresR23
.model vresR23 r(  )

*## Multisim Component U5 ##*
xU5_B 30 26 0 VEE VCC NE5532_2__OPAMP__1

*## Multisim Component U5 ##*
xU5_A 25 24 0 VEE VCC NE5532_2__OPAMP__1

*## Multisim Component R22 ##*
rR22 22 23 100 vresR22
.model vresR22 r(  )

*## Multisim Component R21 ##*
rR21 21 22 10 vresR21
.model vresR21 r(  )

*## Multisim Component R20 ##*
rR20 20 21 1000 vresR20
.model vresR20 r(  )

*## Multisim Component R19 ##*
rR19 10 20 100 vresR19
.model vresR19 r(  )

*## Multisim Component U4 ##*
xU4_B 23 22 0 VEE VCC NE5532_2__OPAMP__1

*## Multisim Component U4 ##*
xU4_A 21 20 0 VEE VCC NE5532_2__OPAMP__1

*## Multisim Component R6 ##*
rR6 8 6 80600 vresR6
.model vresR6 r(  )

*## Multisim Component R18 ##*
rR18 19 18 73200 vresR18
.model vresR18 r(  )

*## Multisim Component C12 ##*
cC12 19 17 1.2e-009

*## Multisim Component C11 ##*
cC11 17 18 1.2e-008

*## Multisim Component R17 ##*
rR17 17 0 243 vresR17
.model vresR17 r(  )

*## Multisim Component R16 ##*
rR16 16 17 66500 vresR16
.model vresR16 r(  )

*## Multisim Component R15 ##*
rR15 16 15 162000 vresR15
.model vresR15 r(  )

*## Multisim Component C10 ##*
cC10 16 14 1.2e-009

*## Multisim Component C9 ##*
cC9 14 15 1.2e-008

*## Multisim Component R14 ##*
rR14 14 0 133 vresR14
.model vresR14 r(  )

*## Multisim Component R13 ##*
rR13 13 14 66500 vresR13
.model vresR13 r(  )

*## Multisim Component R12 ##*
rR12 13 12 15000 vresR12
.model vresR12 r(  )

*## Multisim Component C7 ##*
cC7 11 12 1.2e-008

*## Multisim Component R10 ##*
rR10 11 0 11 vresR10
.model vresR10 r(  )

*## Multisim Component R2 ##*
rR2 4 2 15000 vresR2
.model vresR2 r(  )

*## Multisim Component C2 ##*
cC2 4 1 3.3e-010

*## Multisim Component C1 ##*
cC1 1 2 1.2e-008

*## Multisim Component R1 ##*
rR1 1 0 40.2 vresR1
.model vresR1 r(  )

*## Multisim Component R11 ##*
rR11 3 1 80600 vresR11
.model vresR11 r(  )

*## Multisim Component R8 ##*
rR8 10 9 82500 vresR8
.model vresR8 r(  )

*## Multisim Component C6 ##*
cC6 10 6 3.3e-010

*## Multisim Component C5 ##*
cC5 6 9 1.2e-008

*## Multisim Component R7 ##*
rR7 6 0 86.6 vresR7
.model vresR7 r(  )

*## Multisim Component U2 ##*
xU2_B 10 9 0 VEE VCC NE5532_2__OPAMP__1

*## Multisim Component R5 ##*
rR5 8 7 182000 vresR5
.model vresR5 r(  )

*## Multisim Component C4 ##*
cC4 8 5 3.3e-010

*## Multisim Component R4 ##*
rR4 5 0 47.5 vresR4
.model vresR4 r(  )

*## Multisim Component R3 ##*
rR3 4 5 80600 vresR3
.model vresR3 r(  )

*## Multisim Instrument XFG1 ##*
XFG1 XFG1_OPEN_3 0 3 XXFG1_90314848

*## Multisim Component U3 ##*
xU3_B 19 18 0 VEE VCC NE5532_2__OPAMP__1

*## Multisim Component U3 ##*
xU3_A 16 15 0 VEE VCC NE5532_2__OPAMP__1

*## Multisim Component U2 ##*
xU2_A 13 12 0 VEE VCC NE5532_2__OPAMP__1

*## Multisim Component U1 ##*
xU1_B 8 7 0 VEE VCC NE5532_2__OPAMP__1

*## Multisim Component U1 ##*
xU1_A 4 2 0 VEE VCC NE5532_2__OPAMP__1

.SUBCKT NE5532_2__OPAMP__1 1 2 3 4 5
* EWB Version 4 - 5 Terminal Opamp Model
* nodes: 3=+ 2=- 1=out 5=V+ 4=V-
* VCC= 10 VEE= -10 CC= 3e-011 A= 75000 RI= 300000
* RO= 0.3 VOS= 0.0005 IOS= 1e-008 IBS= 2e-007
* VSW+= 13 VSW-= -13 CMMR= 100
* ISC= 0.038 SR= 9 Fu= 1e+007 Pm= 3.60934e-009
    VC 5 15 DC -3.36781V
    VE 12 4 DC -3.36781V
    IEE 10 4 DC 0.0002704A
    R1  10  0 10Gohm
    R6  11  0 100Kohm
    R7   5  4 1Kohm
    Rc1  6  5 530.516ohm
    Rc2  5  7 530.516ohm
    Re1  9 10 338.534ohm
    Re2  8 10 338.534ohm
    Ro1  1 14 0.15ohm
    Ro2 14  0 0.15ohm
    Ree 10  0 739645ohm
    Rcc  0 13 7.95871e-010ohm
    Cee  0 10 1e-012
    Cc  14 11 3e-011
    C1   6  7 1e-016
    GA  11  0  6  7 0.00188496
    GC   0 13  1  0 1.25649e+009
    GB  14  0 11  0 2652.58
    GCM  0 11 10  0 1.88496e-008
    D1  14 13 Dopamp1
    D2  13 14 Dopamp1
    D3   1 15 Dopamp2
    D4  12  1 Dopamp2
    Qt1  6 2 9 Qopamp1
    Qt2  7 3 8 Qopamp2
.MODEL Dopamp1 D (Is=5.745e-16A Rs=0 Cjo=0F Vj=750mV Tt=0s M=0)
.MODEL Dopamp2 D (Is=8e-016A Rs=0 Cjo=0F Vj=750mV Tt=0s M=0)
.MODEL Qopamp1 NPN (Is=8e-016A BF=658.537 BR=960m
+       Rb=0ohm Re=0ohm Rc=0ohm Cjs=0F Cje=0F Cjc=0F
+       Vje=750m Vjc=750m Tf=0 Tr=0 mje=0 mjc=0 VA=50)
.MODEL Qopamp2 NPN (Is=8.15474e-016A BF=692.308 BR=960m
+       Rb=0ohm Re=0ohm Rc=0ohm Cjs=0F Cje=0F Cjc=0F
+       Vje=750m Vjc=750m Tf=0 Tr=0 mje=0 mjc=0 VA=50)
.ENDS

.subckt XXFG1_90314848 1 2 3
vfgen_src_positive 3 2 dc 0.000000e+000 ac 1.500000000000000000e+001 pulse(-1.500000000000000000e+001 1.500000000000000000e+001 0 1.000000000000000000e-008 1.000000000000000000e-008 4.999000000000000100e-005 1.000000000000000000e-004)
vfgen_src_negative 2 1 dc 0.000000e+000 ac 1.500000000000000000e+001 pulse(-1.500000000000000000e+001 1.500000000000000000e+001 0 1.000000000000000000e-008 1.000000000000000000e-008 4.999000000000000100e-005 1.000000000000000000e-004)
.ends
